# Keil uVision project TJGroundStation.uvprojx, settings and files
target TJGroundStation (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: TJGroundStation +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Inc;                            ../Drivers/STM32F4xx_HAL_Driver/Inc;                            ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                            ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                            ../Drivers/CMSIS/Include;                            ..\MDK-ARM;                            ..\Drivers\HARDWARE;                            ..\DSP\Include;                            ..\DSP;                         ../Middlewares/Third_Party/FatFs/src
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User
    ./: console.c pwr_mgt.c
    ../Src/: main.c user_diskio.c fatfs.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_sdram.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/HARDWARE
    ./: MPU.c MS.c W25.c RTC.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c LTC2944.c ADC.c HTU.c NAND.c SRAM.c SD.c
  group Algroithm/SOFTWARE
    ./: IMU.c mat.c
  group DSP
    ../DSP/: arm_cortexM4lf_math.lib
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
software components: CMSIS:CORE 4.3.0
